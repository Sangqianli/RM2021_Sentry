# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,__TARGET_FPU_VFP
  c misc: --c99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\SYSTEM;..\Drivers\Include;..\Libraries\cmsis;..\BMI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: system.c stm32f4xx_it.c main.c pid.c mode.c launcher.c gimbal.c chassis.c judge.c kalman.c visual_process.c
  group BSP
    ../BSP/: can1.c control.c can2.c usart2.c crc.c led.c pwm.c usart5.c time1.c io.c anoc.c laser.c iic.c myiic.c
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c
    ../BSP/: vision.c
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/cmsis/: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/: usart.c sys.c
  group Drivers/CMSIS
    ../Drivers/Device/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c arm_cos_f32.c arm_sin_f32.c
  group BMI
    ../BMI/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c spi2.c
